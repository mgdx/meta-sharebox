SHAREBOX_BUNDLE_ENGINE = "full"
require sharebox-bundle.inc
