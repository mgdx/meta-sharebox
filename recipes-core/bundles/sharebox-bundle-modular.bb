SHAREBOX_BUNDLE_ENGINE = "modular"
require sharebox-bundle.inc
